# Keil uVision project IAP.uvproj, settings and files
target STM3210E-EVAL (ARM-ADS)
  device: STM32F101VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o IAP.bin Obj\IAP.axf
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Application;..\kmy_platform;..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Application/: common.c download.c gprs.c Input.c main.c stm32f10x_it.c ymodem.c
  group kmy_platform
    ../kmy_platform/: kmy_FlashDrv.h kmy_GprsDrv.h kmy_keydrv.h kmy_LCDDrv.h kmy_LowPowerDrv.h kmy_Time.h kmy_USART1Drv.h kmy_USART3Drv.h kmy_EEPROMDrv.h kmy_WiFi_SPI.h kmy_WiFi_USARTDrv.h kmy_iap_drv.lib
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/MDK_startup/: startup_stm32f10x_hd_vl.s
  group STM32_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
