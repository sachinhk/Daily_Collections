# Keil uVision project MDKProject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o output\main.bin obj\main.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Application;..\kmy_platform;..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../Application/: base64.c CallRecord.c Cursor.c des.c EepromFileSystem.c FileOperate.c FormInput.c gprs.c key.c lcd.c main.c MenuOperate.c message.c my_library.c my_menuop.c mypure_library.c PhoneBook.c SelfTest.c setting.c ShuRuFa.c sim900B.c Tool.c ucs2_to_GB2312.c Transaction.c kmy_wifi.c BarCode.c global_variable.h global_extern_variable.h frontend.c GlobalVar.h GlobalVariable.h collection.c addmenu.c clearmemory.c flash.c keyboard.c myprintf.c viewdetails.c popup.c Transaction.h pendingorder.c header.c footer.c changepass.c ReadFromModem3.c InitializeModem.c parseMsg1.c StoreMSG.c sigstrength.c parseMsg1.h MsgSend.c
  group kmy_platform
    ../kmy_platform/: kmy_Adc.h kmy_BattaryDrv.h kmy_BeepDrv.h kmy_EEPROMDrv.h kmy_FlashDrv.h kmy_GprsDrv.h kmy_keydrv.h kmy_LCDDrv.h kmy_LowPowerDrv.h kmy_MagcardDrv.h kmy_Misc.h kmy_PrinterDrv.h kmy_psamDrv.h kmy_TamperDrv.h kmy_Time.h kmy_USART1Drv.h kmy_USART3Drv.h kmy_WiFi_SPI.h kmy_WiFi_USARTDrv.h kmy_RFDrv.h kmy_app_drv.lib
  group STM32F10x_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/MDK_startup/: startup_stm32f10x_hd_vl.s
    ../CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
